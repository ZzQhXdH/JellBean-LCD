# Keil uVision project JellyBean.uvprojx, settings and files
target JellyBean (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JellyBean
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, __TARGET_FPU_VFP,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\CMSIS;..\User;..\STemWin\OS;..\STemWin\Config;..\STemWin\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group User
    ../User/: main.cpp
  group User/Task
    ../User/Task/: Task.cpp GUITask.cpp DeliverUartTask.cpp
  group User/Driver
    ../User/Driver/: LogUart.cpp KeyUart.cpp Lcd.c DeliverUart.cpp FlashMemory.cpp
  group User/Event
    ../User/Event/: Event.cpp Receiver.cpp Sender.cpp LogEvent.cpp KeyEvent.cpp DeliverEvent.cpp Timer.cpp
  group STemWin
    ../STemWin/Config/: LCDConf.c GUIConf.c GUIDRV_Template.c
    ../STemWin/OS/: GUI_X_OS.c
    ../STemWin/: STemWin540_CM4_OS_Keil_ot.lib
  group GUI
    ../User/GUI/: UiPolygon.cpp BackgroundWindow.cpp PasswordWindow.cpp SystemConfigWindow.cpp ChangePINWindow.cpp BaseWindow.cpp UiProgBar.cpp PriceWindow.cpp SettingPriceWindow.cpp UiStatus.cpp PayWindow.cpp StatusWindow.cpp
  group Resource
    ../User/Resource/: StringResources.cpp
  group Custom
    ../User/Custom/: WaresInfo.cpp WaresManager.cpp BaseOutput.cpp KeyQueue.cpp BaseBuffer.cpp MDBManager.cpp
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, CMSIS:RTOS2:Keil RTX5 5.3.0
